# Keil uVision project Project.uvprojx, settings and files
target GD32E230C_EVAL (6160000::V6.16::ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: GD32E230C_EVAL
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230
  c include: ..\CMSIS;..\GD32E23x_FWLib\Include;..\USER;..\Hardware\led;..\Hardware\i2cSlave;..\Hardware\uart;..\Hardware\spiMaster;..\Hardware\i2cMaster
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ../USER/: main.c gd32e23x_it.c systick.c
  group CMSIS
    ../CMSIS/: system_gd32e23x.c
  group GD32E23x_Peripherals
    ../GD32E23x_FWLib/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group Startup
    ../CMSIS/: startup_gd32e23x.s
  group Hardware
    ../Hardware/led/: led.c
    ../Hardware/i2cSlave/: i2cSlave.c
    ../Hardware/uart/: uart.c
    ../Hardware/spiMaster/: spiMaster.c
    ../Hardware/i2cMaster/: i2cMaster.c
software components: CMSIS:CORE 5.0.2
